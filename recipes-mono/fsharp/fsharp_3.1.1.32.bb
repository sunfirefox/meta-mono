require fsharp.inc

inherit pkgconfig

SRC_URI[md5sum] = "6fa9a52ffe8b6d0a26330a8d6ac8f17e"
SRC_URI[sha256sum] = "cdb966e271195bd7f7016fa1555e8f16184a0b3d8fb09acaee95020f7a7b789a"

